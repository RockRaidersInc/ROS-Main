Commit message: time-elastic-band planner added, lane_detection_6.py added

File: zed/urdf/zed.urdf (robot description, URDF)
Before this commit: robot zed_camera, 6 links, 5 joints
Joints:
- joint zed_camera_center_joint: origin xyz=0 0 1.2 rpy=0 0.5235988 0 -> xyz=0.1 0 1.2 rpy=0 0.5235988 0
